# Keil uVision project STM32F469NI.uvprojx, settings and files
target STM32F469NI (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x50000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F469NI +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F469xx
  c include: ..\hal\inc;..\startup;..\user;..\hal\inc\Legacy;..\driver\led
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group doc
    ../: readme.md
  group startup
    ../startup/: startup_stm32f469xx.s system_stm32f4xx.c
  group hal
    ../hal/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c
  group driver
    ../driver/led/: bsp_led.c
  group user
    ../user/: stm32f4xx_it.c stm32f4xx_hal_conf.h stm32f4xx_main.c
